# IAR project LPC-P1343_VirtualComPort_LEDs&Buttons.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1343_SK
  ICCARM.CCIncludePath2: ; app; board; modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBMouse.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\LPC1343_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s main.c readme.txt
  group app
    app/: cd_class.c uart.c usb_dev_desc.c usb_hooks.c
  group modules
    modules/: usb_buffer.c usb_hw.c usb_t9.c
