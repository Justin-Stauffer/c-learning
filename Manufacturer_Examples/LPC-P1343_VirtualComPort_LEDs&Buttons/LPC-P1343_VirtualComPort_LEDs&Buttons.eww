<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPC-P1343_VirtualComPort_LEDs&amp;Buttons.ewp</path>
  </project>
  <batchBuild/>
</workspace>


