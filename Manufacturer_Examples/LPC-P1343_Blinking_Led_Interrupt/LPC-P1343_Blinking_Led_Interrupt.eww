<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPC-P1343_Blinking_Led_Interrupt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


