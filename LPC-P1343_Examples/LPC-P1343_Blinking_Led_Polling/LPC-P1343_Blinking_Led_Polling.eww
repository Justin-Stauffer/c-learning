<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPC-P1343_Blinking_Led_Polling.ewp</path>
  </project>
  <batchBuild/>
</workspace>


